<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>ECE350</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>FM receiver</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Eye diagram delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>150</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, 50000, 20000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>label</key><value>RF gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rtl_freq</value></param>
<param><key>value</key><value>142.17e6</value></param>
<param><key>label</key><value>Coarse Center Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100e6</value></param>
<param><key>step</key><value>10000</value></param>
<param><key>stop</key><value>950e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>xlate_tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Fine Center Frequenc</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>eyediagram</key>
<param><key>id</key><value>eyediagram_0</value></param>
<param><key>delay</key><value>delay</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>rtl_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate*10</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>label0</key><value>s(t) waterfall</value></param>
<param><key>label1</key><value>Filtered s(t) spectrum</value></param>
<param><key>label2</key><value>m(t) eye diagram</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>xlating_fir_filter</value></param>
<param><key>center_freq</key><value>-xlate_tune</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>eyediagram_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>xlating_fir_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
